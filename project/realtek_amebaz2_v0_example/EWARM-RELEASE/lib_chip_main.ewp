# IAR project lib_chip_main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8710C; __ARM_ARCH_8M_MAIN__=1; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; V8M_STKOVF; CONFIG_SYSTEM_TIME64=0; CHIP_PROJECT=1; CHIP_DEVICE_LAYER_TARGET=Ameba; MBEDTLS_CONFIG_FILE=\"mbedtls_config.h\"; LWIP_IPV6_ND=1; LWIP_IPV6_SCOPES=0; LWIP_PBUF_FROM_CUSTOM_POOLS=0; LWIP_IPV6_ROUTE_TABLE_SUPPORT=1; CHIP_DEVICE_LAYER_NONE=0; CHIP_SYSTEM_CONFIG_USE_ZEPHYR_NET_IF=0; CHIP_SYSTEM_CONFIG_USE_BSD_IFADDRS=0; CHIP_SYSTEM_CONFIG_USE_ZEPHYR_SOCKET_EXTENSIONS=0; CHIP_SYSTEM_CONFIG_USE_LWIP=1; CHIP_SYSTEM_CONFIG_USE_SOCKETS=0; CHIP_SYSTEM_CONFIG_USE_NETWORK_FRAMEWORK=0; CHIP_SYSTEM_CONFIG_POSIX_LOCKING=0; INET_CONFIG_ENABLE_IPV4=1; USE_ZAP_CONFIG; CHIP_HAVE_CONFIG_H
  ICCARM.IExtraOptions: --cmse; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\component\soc\realtek\8710c\cmsis\rtl8710c\lib\include; ..\..\..\component\soc\realtek\8710c\fwlib\include; ..\..\..\component\soc\realtek\8710c\fwlib\lib\include; ..\..\..\component\soc\realtek\8710c\cmsis\cmsis-core\include; ..\..\..\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\component\soc\realtek\8710c\app\rtl_printf\include; ..\..\..\component\soc\realtek\8710c\app\shell; ..\..\..\component\soc\realtek\8710c\app\stdio_port; ..\..\..\component\soc\realtek\8710c\misc\utilities\include; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.0.1\Source\include; ..\..\..\component\os\freertos\freertos_v10.0.1\Source\portable\IAR\ARM_RTL8710C; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network\include; ..\..\..\component\common\application; ..\..\..\component\common\application\mqtt\MQTTClient; ..\..\..\component\common\example; ..\..\..\component\common\file_system; ..\..\..\component\common\file_system\dct; ..\..\..\component\common\file_system\ftl; ..\..\..\component\common\utilities; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8710c; ..\..\..\component\soc\realtek\8710c\mbed-drivers\include; ..\..\..\component\os\os_dep\include; ..\..\..\component\common\network; ..\..\..\component\common\network\coap\include; ..\..\..\component\common\network\http2\nghttp2-1.31.0\includes; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\mbed\targets\hal\rtl8710c; ..\..\..\component\common\test; ..\..\..\component\common\bluetooth\realtek\sdk; ..\..\..\component\common\bluetooth\realtek\sdk\inc; ..\..\..\component\common\bluetooth\realtek\sdk\inc\app; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\component\common\bluetooth\realtek\sdk\inc\os; ..\..\..\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\..\component\common\bluetooth\realtek\sdk\inc\stack; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\lib; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src\data_uart; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src\hci; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src\os; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src\vendor_cmd; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_config; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_central; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_peripheral; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_scatternet; ..\..\..\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\..\component\soc\realtek\8710c\misc\platform; ..\..\..\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\component\soc\realtek\8710c\misc\driver; ..\..\..\component\soc\realtek\8710c\misc\os; ..\..\..\component\common\drivers\wlan\realtek\src\core\option; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src\crypto; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\..\component\common\network\libcoap\include; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\cmd; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\common; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\gap; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc\amebaz2; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model\realtek; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\platform; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\provisioner; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\device; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_device_rtk_demo; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo\inc; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\device; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\provisioner; ..\..\..\component\common\media\rtp_codec; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_airsync_config; ..\..\..\component\common\application\airsync\1.0.4; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\device_multiple_profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\provisioner_multiple_profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_test; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_fuzz_test; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_ota_central_client; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_harmony_adapter; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_datatrans; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_matter_adapter; ..\..\..\third_party\connectedhomeip\zzz_generated\app-common; ..\..\..\third_party\connectedhomeip\zzz_generated\all-clusters-app; ..\..\..\third_party\connectedhomeip\zzz_generated\all-clusters-app\zap-generated; ..\..\..\third_party\connectedhomeip\examples\all-clusters-app\all-clusters-common; ..\..\..\third_party\connectedhomeip\examples\all-clusters-app\all-clusters-common\include; ..\..\..\third_party\connectedhomeip\examples\all-clusters-app\ameba\main\include; ..\..\..\third_party\connectedhomeip\examples\all-clusters-app\ameba\build\chip\gen\include; ..\..\..\third_party\connectedhomeip\src\include; ..\..\..\third_party\connectedhomeip\src\lib; ..\..\..\third_party\connectedhomeip\src; ..\..\..\third_party\connectedhomeip\third_party\nlassert\repo\include; ..\..\..\third_party\connectedhomeip\src\app; ..\..\..\third_party\connectedhomeip\src\app\util; ..\..\..\third_party\connectedhomeip\src\app\server; ..\..\..\third_party\connectedhomeip\src\controller\data_model; ..\..\..\third_party\connectedhomeip\third_party\nlio\repo\include; ..\..\..\third_party\connectedhomeip\third_party\nlunit-test\repo\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  prebuild: CSCRIPT  "..\..\..\component\soc\realtek\8710c\misc\iar_utility\prebuild.vbs" "$PROJ_DIR$" "$PROJ_FNAME$"
  postbuild: CSCRIPT  "..\..\..\component\soc\realtek\8710c\misc\iar_utility\postbuild_version.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$PROJ_FNAME$" "$TOOLKIT_DIR$"
  ILINK.IlinkOutputFile: lib_dct.out
  group app/clusters
    ../../../third_party/connectedhomeip/src/app/clusters/access-control-server/: access-control-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/account-login-server/: account-login-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/administrator-commissioning-server/: administrator-commissioning-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/application-basic-server/: application-basic-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/application-launcher-server/: application-launcher-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/audio-output-server/: audio-output-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/barrier-control-server/: barrier-control-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/basic/: basic.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/bindings/: bindings.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/channel-server/: channel-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/color-control-server/: color-control-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/content-launch-server/: content-launch-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/descriptor/: descriptor.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/diagnostic-logs-server/: diagnostic-logs-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/door-lock-server/: door-lock-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/ethernet-network-diagnostics-server/: ethernet-network-diagnostics-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/fixed-label-server/: fixed-label-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/general-commissioning-server/: general-commissioning-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/general-diagnostics-server/: general-diagnostics-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/group-key-mgmt-server/: group-key-mgmt-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/groups-server/: groups-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/ias-zone-server/: ias-zone-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/identify-server/: identify-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/keypad-input-server/: keypad-input-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/level-control/: level-control.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/low-power-server/: low-power-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/media-input-server/: media-input-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/media-playback-server/: media-playback-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/mode-select-server/: mode-select-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/network-commissioning-old/: network-commissioning-ember.cpp network-commissioning-old.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/occupancy-sensor-server/: occupancy-sensor-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/on-off-server/: on-off-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/operational-credentials-server/: operational-credentials-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/ota-provider/: ota-provider.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/power-source-configuration-server/: power-source-configuration-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/pump-configuration-and-control-server/: pump-configuration-and-control-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/scenes/: scenes.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/software-diagnostics-server/: software-diagnostics-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/switch-server/: switch-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/target-navigator-server/: target-navigator-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/test-cluster-server/: test-cluster-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/thermostat-server/: thermostat-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/thermostat-user-interface-configuration-server/: thermostat-user-interface-configuration-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/thread-network-diagnostics-server/: thread-network-diagnostics-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/user-label-server/: user-label-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/wifi-network-diagnostics-server/: wifi-network-diagnostics-server.cpp
    ../../../third_party/connectedhomeip/src/app/clusters/window-covering-server/: window-covering-server.cpp
  group app/reporting
    ../../../third_party/connectedhomeip/src/app/reporting/: Engine.cpp
  group app/server
    ../../../third_party/connectedhomeip/src/app/server/: CommissioningWindowManager.cpp Dnssd.cpp EchoHandler.cpp OnboardingCodesUtil.cpp Server.cpp
  group app/util
    ../../../third_party/connectedhomeip/src/app/util/: af-event.cpp af-main-common.cpp attribute-size-util.cpp attribute-storage.cpp attribute-table.cpp binding-table.cpp chip-message-send.cpp CHIPDeviceCallbacksMgr.cpp client-api.cpp DataModelHandler.cpp ember-compatibility-functions.cpp ember-print.cpp error-mapping.cpp esi-management.cpp message.cpp process-cluster-message.cpp process-global-message.cpp util.cpp
  group example/all-clusters-common
    ../../../third_party/connectedhomeip/examples/all-clusters-app/all-clusters-common/src/: bridged-actions-stub.cpp ota-requestor-stub.cpp static-supported-modes-manager.cpp
  group example/ameba
    ../../../third_party/connectedhomeip/examples/all-clusters-app/ameba/main/: CHIPDeviceManager.cpp chipinterface.cpp DeviceCallbacks.cpp DsoHack.cpp Globals.cpp LEDWidget.cpp
  group zzz_generated/all-clusters-app
    ../../../third_party/connectedhomeip/zzz_generated/all-clusters-app/zap-generated/: callback-stub.cpp CHIPClientCallbacks.cpp CHIPClusters.cpp IMClusterCommandHandler.cpp
  group zzz_generated/app-common
    ../../../third_party/connectedhomeip/zzz_generated/app-common/app-common/zap-generated/attributes/: Accessors.cpp
    ../../../third_party/connectedhomeip/zzz_generated/app-common/app-common/zap-generated/: cluster-objects.cpp
